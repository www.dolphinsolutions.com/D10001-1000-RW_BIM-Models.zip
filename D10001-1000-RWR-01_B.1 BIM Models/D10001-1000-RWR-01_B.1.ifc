Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowTerminal: DC1300-PAN:Standard, DC1300-PAN:Standard:1094414
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Offset from Host: 0 mm; Host: Level : Level 0
Dimensions - Area: 0.565454 m2; Volume: 0.0338073 m3
Identity Data - Mark: 698
Other - Family: DC1300-PAN: Standard; Family and Type: DC1300-PAN: Standard; Type: DC1300-PAN: Standard; Type Id: DC1300-PAN: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DC1310-GRY:Standard, DC1310-GRY:Standard:1094415
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 460 mm; Height: 20 mm; Width: 375 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_95:WC seats and covers; CodePerformance: DocM; Color: Grey; Constituents: n/a; Description: Grey Toilet seat; DurationUnit: year; ExpectedLife: n/a; Features: antibacterial_seatonly; Finish: n/a; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: ThermosetPlastic; ModelNumber: DC1310-GRY; ModelReference: DolphinSolutionsLimited_ToiletSeat; Name: WCSeatsAndCovers_ToiletSeat_DC1310-GRY_DolphinSolutionsLimited; NBSDescription: WC seats and covers; NBSReference: 45-35-70/391; NBSTypeID: n/a; NominalHeight: 20 mm; NominalLength: 460 mm; NominalWidth: 370 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.05.21.14.11; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 370 x 20 x 460 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_93_95; Uniclass2015Title: WC seats and covers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DC1310-GRY
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletSeat; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WCSeatsAndCovers_ToiletSeat_DC1310-GRY_DolphinSolutionsLimited; Category: Pr_40_20_93_95:WC seats and covers
Pset_DistributionFlowElementCommon - Reference: DC1310-GRY:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 450 mm; Host: Level : Level 0; Offset from Host: 450 mm
Dimensions - Area: 0.103898 m2; Volume: 0.00161082 m3
Identity Data - Mark: 699
Other - Family: DC1310-GRY: Standard; Family and Type: DC1310-GRY: Standard; Type: DC1310-GRY: Standard; Type Id: DC1310-GRY: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DC34.5025:DC34.5025L, DC34.5025:DC34.5025L:1094418
In: Level 0
Type - PredefinedType: WASHHANDBASIN; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 125 mm; Length: 500 mm; Width: 250 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_96_18 Countertop washbasins-Pr_40_20_96_96:Wall-hung wash basins; CAWS: N13/335 Washbasins_N13/30 Washbasins; CodePerformance: n/a; Color: White; Constituents: n/a; Description: Wash basin wall hung or counter mounted rectangular with overflow; DurationUnit: year; ExpectedLife: n/a; Features: tap hole_overflow; Finish: Glossy; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: WASHHANDBASIN; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: Ceramic; ModelNumber: DC34.5025; ModelReference: DolphinSolutionsLimited_Washbasin; Name: Washbasin_RectangularWithOverflow_DC34.5025_DolphinSolutionsLimited; NBSDescription: Countertop washbasins_Wall-hung wash basins; NBSReference: 35-70-70/124; NominalHeight: 125; NominalLength: 500; NominalWidth: 250; ObjectClassification: Omniclass; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; SerialNumber: n/a; Shape: Square; Size: 500w x 250d 125h mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DC34.5025L; Uniclass2015Code: Pr_40_20_96_18-Pr_40_20_96_96; Uniclass2015Title: Countertop washbasins_Wall-hung wash basins; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: DC34.5025; Type: 34.5025L
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Washbasin; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Washbasin_RectangularWithOverflow_DC34.5025_DolphinSolutionsLimited; Category: Pr_40_20_96_18 Countertop washbasins-Pr_40_20_96_96:Wall-hung wash basins
Type - Pset_SanitaryTerminalTypeWashHandBasin - NominalLength: 152400 mm; NominalWidth: 76200 mm; Color: White
Pset_DistributionFlowElementCommon - Reference: DC34.5025:DC34.5025L; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 595 mm; Host: Level : Level 0; Offset from Host: 595 mm
Dimensions - Area: 0.279762 m2; Volume: 0.00883039 m3
Identity Data - Mark: 702
Other - Family: DC34.5025: DC34.5025L; Family and Type: DC34.5025: DC34.5025L; Type: DC34.5025: DC34.5025L; Type Id: DC34.5025: DC34.5025L
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DS213.150.150:DS213.150.150, DS213.150.150:DS213.150.150:1094423
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 125 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; BodyIngressProtectionMinimum: IP68 connector; Category: Pr_40_20_87_98:Washbasin Taps; CodePerformance: WRAS; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: InformBasinTap; DurationUnit: year; ElectricalSupplyFrequency: 50/ 60 Hz; ElectricalSupplyRatedOperationalVoltage: Plug in 9v Transformers 100-240V; ExpectedLife: n/a; Features: Up to 70% water savings_BREEAM/ SKA/ LEED/ WELL/ WRAS/ compliant_Flow rate: Max. 3.0 litres/minute between 0.5 and 6.0 bar_Water supply: single inlet cold or pre-mixed � a TMV2 or TMV3 thermostatic mixing valve is recommended for premixed application; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Form: CounterMounted; Grade: 316; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DS213.150.150; ModelReference: DolphinSolutionsLimited_InformBsainTap; Name: WashBasinTaps_Inform_BasinTap_DS213.150.150_DolphinSolutionsLimited; NBSDescription: WashbasinTaps; NBSReference: 45-35-70/371; NBSTypeID: n/a; NominalHeight: 150 mm; NominalLength: 150 mm; NominalWidth: 22 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.55.17; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-inform-basin-tap-2/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 150 x 150 x 22 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DS213.150.150; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin Taps; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DS213.150.150
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_InformBsainTap; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WashBasinTaps_Inform_BasinTap_DS213.150.150_DolphinSolutionsLimited; Category: Pr_40_20_87_98:Washbasin Taps
Pset_DistributionFlowElementCommon - Reference: DS213.150.150:DS213.150.150; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 720 mm; Host: Level : Level 0; Offset from Host: 720 mm
Dimensions - Area: 0.0207593 m2; Volume: 0.0000445686 m3
Identity Data - Mark: 707
Other - AL0220: yes; Family: DS213.150.150: DS213.150.150; Family and Type: DS213.150.150: DS213.150.150; Type: DS213.150.150: DS213.150.150; Type Id: DS213.150.150: DS213.150.150
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC754:BC754, BC754:BC754:1094412
In: Level 0
Type - Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 200 mm; Height: 50 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_78:Shelves; CAWS: N13/449 Shelves; CodePerformance: n/a; Color: Brushed Satin_RAL Colours; Constituents: n/a; Description: Shelf; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin_PowderCoated; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: Shelf; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: BC754; ModelReference: DolphinSolutionsLimited_Shelf; Name: Shelves_Shelf_BC754_DolphinSolutionsLimited; NBSDescription: Shelves; NBSReference: 45-35-80/320; NBSTypeID: n/a; NominalHeight: 50; NominalLength: 400; NominalWidth: 200; ObjectClassification: 23.40.20.27.11; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.11; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 200 x 400 x 50 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC754; Uniclass2015Code: Pr_40_30_78_78; Uniclass2015Title: Shelves; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Materials and Finishes - Primary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: BC754
Type - Pset_ElementShading - Color: Brushed Satin_RAL Colours
Type - Pset_FurnitureTypeCommon - Description: Shelf; NominalHeight: 15240 mm; NominalLength: 121920 mm
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Shelf; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Shelves_Shelf_BC754_DolphinSolutionsLimited; Category: Pr_40_30_78_78:Shelves
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC754:BC754
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 710 mm; Host: Level : Level 0; Offset from Host: 710 mm
Dimensions - Area: 0.126358 m2; Volume: 0.000250292 m3
Identity Data - Mark: 696
Other - Family: BC754: BC754; Family and Type: BC754: BC754; Type: BC754: BC754; Type Id: BC754: BC754
Phasing - Phase Created: New Construction

# IfcRailing: BC5063-05:BC5063-05, BC5063-05:BC5063-05:1094421
In: Level 0
Type - PredefinedType: HANDRAIL; Material: <Unnamed>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Heigth: 92 mm; Length: 500 mm; Width: 32 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CAWS: N13/69 Support rails and grab bars_N13/436 Handrails and grab bars; CodePerformance: BSEN12182; Color: Brushed Satin_Various; Constituents: n/a; Description: 500mm long roseless 32mm grab rail; DurationUnit: year; ExpectedLife: n/a; Features: Roseless 60mm wall clearance; Finish: Brushed Satin_Suffix.5-PowderCoated_.6-CeramicCoated; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcRailingType; IfcExportType: HANDRAIL; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: BC5063-05; ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Name: SupportRails_Roseless32mmGrabRail_BC5063-05_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 92 mm; NominalLength: 500 mm; NominalWidth: 32 mm; ObjectClassification: 23.40.20.27.14; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: BC5063-05; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 500 x 32 x 92 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5063-05; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5063-05
Type - Pset_ElementShading - Color: Brushed Satin_Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Type - Pset_ProductRequirements - Name: SupportRails_Roseless32mmGrabRail_BC5063-05_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Type - Pset_RailingCommon - IsExternal: no
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5063-05:BC5063-05
Pset_RailingCommon - Reference: BC5063-05:BC5063-05
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 664 mm; Host: Level : Level 0; Offset from Host: 664 mm
Dimensions - Area: 0.0310315 m2; Volume: 0.000483638 m3
Identity Data - Mark: 705
Other - Family: BC5063-05: BC5063-05; Family and Type: BC5063-05: BC5063-05; Type: BC5063-05: BC5063-05; Type Id: BC5063-05: BC5063-05
Phasing - Phase Created: New Construction
